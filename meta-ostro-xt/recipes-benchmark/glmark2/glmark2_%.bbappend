# Enable C++11 features
CXXFLAGS += "--std=c++11"
